Commit message: commit all

File: arm_sim/arm_description/urdf/arm.urdf (robot description, URDF)
Before this commit: robot robot, 10 links, 9 joints
Links:
- added link laser
Joints:
- added joint ridar_joint: type fixed, parent base, child laser, origin xyz=0 0.06 0.03 rpy=0 0 -1.57
